# johnblue: no additional FIT image signing keys needed (SOCSEC_SIGN_ENABLE = "0").
# This bbappend exists to confirm the recipe is recognised by the layer and to
# document that the default obmc-phosphor-initramfs + zImage FIT image produced
# by the upstream linux-yocto-fitimage.bb is sufficient for QEMU development.
